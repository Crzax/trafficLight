# Keil uVision project ProgramCode.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ProgramCode +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h LED.h LED.c Timer.c Timer.h Key.h Key.c Buzzer.c Buzzer.h MatrixKey.c MatrixKey.h TrafficLight.h Int0.c Int0.h IR.c IR.h
